# IAR project STM32F103RC.ewp, settings and files
configuration STM32F103RC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F103RC.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F1xx_HAL_Driver
    ./: 
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f1xx.c
  group Middlewares
    ./: 
  group Middlewares/FatFs
    ./: 
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: fatfs.c spi.c sdio.c stm32f1xx_hal_msp.c main.c stm32f1xx_it.c gpio.c usart.c bsp_driver_sd.c
  group Application/EWARM
    ./:  startup_stm32f103xe.s
