# Keil uVision project STM32F103RC.uvprojx, settings and files
target STM32F103RC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\Middlewares\Third_Party\lwip\src\api;..\Middlewares\Third_Party\lwip\src\arch;..\Middlewares\Third_Party\lwip\src\include;..\Middlewares\Third_Party\lwip\src\include\ipv4;..\Middlewares\Third_Party\lwip\src\netif;..\Middlewares\Third_Party\lwip\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: fatfs.c spi.c sdio.c stm32f1xx_hal_msp.c main.c stm32f1xx_it.c gpio.c usart.c bsp_driver_sd.c lwipdemo.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/lwip
    ../Middlewares/Third_Party/lwip/src/arch/: cc.h lwipopts.h perf.h enc28j60.c
    ../Middlewares/Third_Party/lwip/src/netif/: ethernetif.c loopif.c etharp.c slipif.c
    ../Middlewares/Third_Party/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Middlewares/Third_Party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
software components: CMSIS:CORE 5.0.1
